# Keil uVision project Alternating_and_Shifting_LED_and_7_Segment_Display.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Alternating_and_Shifting_LED_and_7_Segment_Display +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Alternating_and_Shifting_LED_and_7_Segment_Display.c
