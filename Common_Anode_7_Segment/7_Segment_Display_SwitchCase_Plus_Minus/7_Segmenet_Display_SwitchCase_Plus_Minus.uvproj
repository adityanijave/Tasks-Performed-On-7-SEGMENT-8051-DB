# Keil uVision project 7_Segmenet_Display_SwitchCase_Plus_Minus.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LED_Plus_Minus +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 7_Segmenet_Display_SwitchCase_Plus_Minus.c
